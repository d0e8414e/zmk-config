## config/Kconfig.defconfig
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

if SHIELD_HOTREUS

config ZMK_KEYBOARD_NAME
    default "hotreus"

endif
```
